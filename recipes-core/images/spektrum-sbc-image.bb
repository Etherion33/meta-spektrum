SUMMARY = "Spektrum SBC production image (compat alias)"
LICENSE = "MIT"

# Keep the original target name as an alias to the production profile.
require recipes-core/images/spektrum-sbc-image-prod.bb
